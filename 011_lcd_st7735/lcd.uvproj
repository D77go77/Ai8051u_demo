# Keil uVision project lcd.uvproj, settings and files
target Project (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LCD +hex
  group User
    ./User/: main.c common.h data.h ai8051u.h
  group Driver
    ./Driver/: mySystem.c myGpio.c myKey.c mySmg.c myAdckey.c myLcd.c
  group App
    ./App/: scheduler.c ui.c
  group COMM
    ./COMM/: stc32_stc8_usb.h stc_usb_cdc_32.LIB

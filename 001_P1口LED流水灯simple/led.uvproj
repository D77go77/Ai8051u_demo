# Keil uVision project led.uvproj, settings and files
target LED (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: led +hex
  group User
    ./User/: main.c common.h
  group Driver
    ./Driver/: myDelay.c myLed.c
  group COMM
    ./COMM/: usb_hid_32.LIB usb.h

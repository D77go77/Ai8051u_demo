# Keil uVision project led.uvproj, settings and files
target LED (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: led +hex
  group User
    ./User/: main.c common.h
  group Driver
    ./Driver/: myMath.c myDelay.c myTime.c myKey.c myLed.c myCtrl.c mySmg.c myOnewire.c myRtc.c myI2c.c myWave.c myUart.c
  group App
    ./App/: scheduler.c
  group COMM
    ./COMM/: stc32_stc8_usb.h stc_usb_cdc_32.LIB
